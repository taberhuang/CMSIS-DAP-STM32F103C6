# Keil uVision project CMSIS-DAP.uvprojx, settings and files
target CMSIS-DAP (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS-DAP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_LD BLUEPILL CDC_UART_USE_USART1_PA9_PA10 NRESET_1MS_TOGGLE_TEST
  c include: ..\CMSIS-DAP;..\Core;..\User;..\USB;..\USB\Keil_USBStack\inc;..\Driver\inc;..\Driver\STM32F10x_ARM_Driver;..\ARM\CMSIS\INC;..\ARM\CMSIS\Driver\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./: main.c stm32f10x_conf.h system_stm32f10x.c
    ../CORE/: startup_stm32f10x_ld.s
  group CMSIS-DAP
    ../CMSIS-DAP/: DAP_config.h DAP.h DAP.c JTAG_DP.c SW_DP.c SWO.c
  group Core
    ../Core/: core_cm3.c
  group Driver
    ../Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_rcc.c
  group USART
    ../Driver/STM32F10x_ARM_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c USART_STM32F10x.c
  group USB
    ../USB/Keil_USBStack/src/: usbd_core.c usbd_core_hid.c usbd_core_cdc.c usbd_hid.c usbd_cdc_acm.c
    ../USB/: usb_config.c usbd_STM32F103.c usbd_user_cdc_acm.c usbd_user_hid.c
